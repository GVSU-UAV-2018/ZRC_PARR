<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ant_rec</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>SNR</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>collar_freq</value></param>
<param><key>value</key><value>150.742e6-3000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>192000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>funcube_replacement</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_udp_sink</key>
<param><key>id</key><value>blocks_udp_sink_0</value></param>
<param><key>ipaddr</key><value>192.168.1.6</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>fcdproplus_fcdproplus</key>
<param><key>id</key><value>fcdproplus_fcdproplus_0</value></param>
<param><key>device_name</key><value></value></param>
<param><key>freq</key><value>collar_freq - 3000</value></param>
<param><key>ppm</key><value>22</value></param>
<param><key>if_gain</key><value>gain</value></param>
<param><key>lnaswitch</key><value>1</value></param>
<param><key>mixergainswitch</key><value>1</value></param>
<param><key>unit</key><value>1</value></param>
</block>
<connection><source_block_id>fcdproplus_fcdproplus_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fcdproplus_fcdproplus_0</source_block_id><sink_block_id>blocks_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
